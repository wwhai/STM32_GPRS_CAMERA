# Keil uVision project gprs-camera.uvprojx, settings and files
target gprs-camera (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gprs-camera +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\core;..\hardware;..\user;..\os;..\stdperiph_lib\inc;..\utils;..\utils\sys;..\hardware\usart;..\hardware\simdevice;..\hardware\timer;..\utils\timer_task;..\hardware\parameter;..\hardware\stmflash;..\utils\user_task;..\hardware\ov2640;..\hardware\23k256;..\hardware\exti
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../hardware/usart/: usart.c
    ../hardware/simdevice/: simdevice.c
    ../hardware/timer/: timer.c
    ../hardware/parameter/: parameter.c
    ../hardware/stmflash/: stmflash.c
    ../hardware/ov2640/: ov2640.c sccb.c
    ../hardware/23k256/: 23k256.c
    ../hardware/exti/: exti.c
  group UTILS
    ../utils/user_task/: user_task.c
    ../utils/timer_task/: timer_task.c
    ../utils/sys/: delay.c sys.c
  group CORE
    ../core/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../stdperiph_lib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_pwr.c stm32f10x_iwdg.c stm32f10x_dma.c
  group README
    ../: README.md
